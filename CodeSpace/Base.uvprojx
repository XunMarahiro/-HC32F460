# Keil uVision project Base.uvprojx, settings and files
target BASE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Base
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c include: .\CMSIS;.\Lib\inc;.\User
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: -keep=*Handler
  group CMSIS
    ./CMSIS/: system_hc32f460.c startup_hc32f460jeta.s
  group Lib
    ./Lib/src/: hc32f460_gpio.c hc32f460_interrupts.c hc32f460_utility.c hc32f460_crc.c hc32f460_i2c.c hc32f460_rtc.c hc32f460_spi.c hc32f460_usart.c
  group User
    ./User/: main.c
software components: CMSIS:CORE 5.5.0
